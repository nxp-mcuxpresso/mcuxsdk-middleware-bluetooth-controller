# IAR project hartt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KW45B41Z83_NBU NXP KW45B41Z83_NBU
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CPU_KW45B41Z83AFPA_NBU; HARTT_ENABLE_FLOAT
  ICCARM.CCIncludePath2: ../../../../../../../../mcu-sdk-2.0\middleware\wireless\ble_controller\src\hadm; ../../../../../../../../mcu-sdk-2.0\components\osa; ../../../../../../../../mcu-sdk-2.0\platform\drivers\common; ../../../../../../../../mcu-sdk-2.0\devices\KW45B41Z83_NBU; ../../../../../../../../mcu-sdk-2.0\CMSIS\Core\Include; ../../../../../../../../mcu-sdk-2.0\devices\KW45B41Z83_NBU\drivers; ../../../../../../../../mcu-sdk-2.0\components\mem_manager; ../../../../../../../../mcu-sdk-2.0\components\lists; ../../../../../../../../mcu-sdk-2.0\middleware\wireless\framework\Common; ../../../../../../../../mcu-sdk-2.0\middleware\wireless\ble_controller\src\hadm\test\hartt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: hartt_vect.h main.c
    ../../: lcl_hadm_hartt.c lcl_hadm_hartt.h
